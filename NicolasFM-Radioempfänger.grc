options:
  parameters:
    generate_options: qt_gui
    id: HF_SSB_RX
    output_language: python
    title: Nicolas Gangl-Prattes FM
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '8'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Nicolas Gangl-Pratte\Downloads\radio.dat
    repeat: 'True'
    type: complex
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '40000'
    decim: '120'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0_0, '0']
- [blocks_file_source_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_file_source_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_file_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
